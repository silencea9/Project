# Keil uVision project Motor_Ctrl.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F305RG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Motor_Ctrl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Firmware\GD32F30x_standard_peripheral\Include;.\TIMER1_pwmout;.\Firmware\CMSIS;.\new_user\soc;.\new_user\inc;.\gd32f30x_lib\source;.\gd32f30x_lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group App
    ./TIMER1_pwmout/: gd32f30x_it.c
  group Firmware
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group MDK_ARM
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group user_soc
    ./new_user/soc/: lcd.c main.c motor.c systick.c valve .c
  group user_inc
    ./new_user/inc/: lcd.h main.h motor.h systick.h valve.h
